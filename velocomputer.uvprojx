# Keil uVision project velocomputer.uvprojx, settings and files
target Target 1 (6160000::V6.16::ARMCLANG)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: velocomputer
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\Velocomputer
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group inc
    ./: SPI.h ADC2_Light.h ADC1_Speed.h USART.h ILI9341.h MPU9250.h TIM.h Symbols.h
  group src
    ./: SPI.c main.c ADC1_Speed.c ADC2_Light.c USART.c ILI9341.c MPU9250.c TIM.c Symbols.c
software components: CMSIS:CORE 5.5.0, Device:STM32Cube LL:ADC 1.7.9, Device:STM32Cube LL:Common 1.7.9, Device:STM32Cube LL:DMA 1.7.9, Device:STM32Cube LL:EXTI 1.7.9, Device:STM32Cube LL:GPIO 1.7.9, Device:STM32Cube LL:PWR 1.7.9, Device:STM32Cube LL:RCC 1.7.9, Device:STM32Cube LL:SPI 1.7.9, Device:STM32Cube LL:TIM 1.7.9, Device:STM32Cube LL:UTILS 1.7.9, Device:Startup 2.6.3
